# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf.exe --bin -o "%L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\app\inc;..\fireware\cmsis\core;..\fireware\cmsis\device;..\fireware\driver\inc;..\driver\led;..\driver\oled;..\driver\debug;..\driver\driver_uart;..\third_lib\freertos\include;..\third_lib\freertos\portable\MemMang;..\third_lib\freertos\portable\RVDS\ARM_CM3;..\third_lib\mqtt\platform\FreeRTOS;..\third_lib\mqtt\mqttclient;..\third_lib\mqtt\network;..\third_lib\mqtt\mqtt;..\third_lib\mqtt\common;..\third_lib\mqtt\common\PLOOC;..\third_lib\ringbuffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/: main.c board.c
    ../app/inc/: FreeRTOSConfig.h
  group driver
    ../driver/oled/: oled.c
    ../driver/led/: led.c
    ../driver/debug/: debug.c
    ../driver/driver_uart/: driver_uart.c
  group fireware
    ../fireware/cmsis/core/: core_cm3.c
    ../fireware/cmsis/device/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
    ../fireware/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group third_lib/freertos
    ../third_lib/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../third_lib/freertos/portable/MemMang/: heap_4.c
    ../third_lib/freertos/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group third_lib/mqtt
    ../third_lib/mqtt/common/: mqtt_list.c random.c
    ../third_lib/mqtt/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../third_lib/mqtt/mqttclient/: mqttclient.c
    ../third_lib/mqtt/network/: nettype_tcp.c network.c
    ../third_lib/mqtt/platform/FreeRTOS/: platform_memory.c platform_mutex.c platform_net_socket.c platform_thread.c platform_timer.c
  group third_lib/ringbuffer
    ../third_lib/ringbuffer/: ringbuffer8.c
